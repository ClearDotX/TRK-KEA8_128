<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\TRK-KEA128_LABTS3.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>TRK-KEA128_LABTS3</project>
        <configuration>Flash Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


