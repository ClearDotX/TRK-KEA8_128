# Keil uVision project TRK-KEA128_Lab3.uvprojx, settings and files
target TRK-KEA128_Lab3 (ARM-ADS)
  device: SKEAZ128xxx4 Freescale
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x3000) IRAM2(0x1FFFF000,0x1000) CPUTYPE("Cortex-M0+") CLOCK(20000000) ELITTLE
  output: TRK-KEA128_Lab3
  c flags: Optim=1
  c include: .\Headers
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3000
  memory RVCT10: RAM 0x1ffff000 size 0x1000
  group Sources
    ./Sources/: ADC.c CLK.c main.c
  group Headers
    ./Headers/: ADC.h CLK.h derivative.h GPIO.h typedefs.h
  group ::Device
    RTE/Device/SKEAZ128xxx4/: startup_SKEAZ1284.s system_SKEAZ1284.c
software components: CMSIS:CORE 3.20.0, Device:Startup 1.0.0
