# IAR project TRK-KEA128_LABTS4.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: KEAZ128xxx4 Freescale KEAZ128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Include
    Include/: CLK.h derivative.h GPIO.h KBI.h typedefs.h
  group Sources
    Sources/: CLK.c KBI.c main.c
  group Startup
    Startup/: cstartup_M_KEA128.s low_level_init.c
