# Keil uVision project TRK-KEA8_Lab2.uvprojx, settings and files
target TRK-KEA8_Lab2 (ARM-ADS)
  device: SKEAZN8xxx4 Freescale
  cpu: IROM(0x00000000,0x2000) IRAM(0x20000000,0x300) IRAM2(0x1FFFFF00,0x100) CPUTYPE("Cortex-M0+") CLOCK(20000000) ELITTLE
  output: TRK-KEA8_Lab2
  c flags: Optim=1
  c include: .\Sources;.\Headers
  memory RVCT4: ROM 0x0 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x300
  memory RVCT10: RAM 0x1fffff00 size 0x100
  group Sources
    ./Sources/: CLK.c FTM.c main.c
  group Headers
    ./Headers/: CLK.h derivative.h FTM.h GPIO.h typedefs.h
  group ::CMSIS
    C:/Keil/ARM/PACK/ARM/CMSIS/3.20.4/CMSIS/Lib/ARM/: arm_cortexM0l_math.lib
  group ::Device
    RTE/Device/SKEAZN8xxx4/: startup_SKEAZN84.s system_SKEAZN84.c
software components: CMSIS:CORE 3.20.0, CMSIS:DSP 1.4.1, Device:Startup 1.0.0
